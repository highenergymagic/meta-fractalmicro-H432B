# SPDX-License-Identifier: MIT
FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI += "file://0001-redundant-unreadable-copy.patch file://0002-propagate-lock-failure.patch"
