# SPDX-License-Identifier: MIT
# Target compilers/binutils come from OE's pinned source recipes.
export KBUILD_BUILD_USER = "builder"
export KBUILD_BUILD_HOST = "openh432-builder"
export KBUILD_BUILD_VERSION = "1"
